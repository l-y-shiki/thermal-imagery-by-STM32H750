# Keil uVision project atk_h750.uvprojx, settings and files
target atk_h750 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Middlewares;..\..\User;..\..\spi_lcd;..\..\MLX90640\functions;..\..\MLX90640\headers;..\..\RGB565;..\..\OVA5640
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c spi_test.c spi_test.h ova5640_demo.c ova5640_demo.h
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dcmi.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c key.h
  group Readme
    ../../: readme.txt
  group spi_lcd
    ../../spi_lcd/: lcd.c lcd.h spi.c spi.h my_i2c.c my_i2c.h 24cxx.c 24cxx.h font.h touch.c gui.c gui.h touch.h
  group MLX90640
    ../../MLX90640/functions/: MLX90640.c MLX90640_API.c MLX90640_SWI2C_Driver.c
    ../../MLX90640/headers/: MYMLX90640.h MYMLX90640_API.h MYMLX90640_I2C_Driver.h
  group RGB565
    ../../RGB565/: rgb565.c rgb565.h
  group OVA5640
    ../../OVA5640/: ova5640.c ova5640.h sccb.c sccb.h ova5640_dcmi.c ova5640_dcmi.h atk_mc5640_cfg.h
